Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-09-22T16:38:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170118_1100(x64) - Exporter 17.0.1117.0 - Alternate UI 17.16.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 22 16:38:55 2020 * Host: 43-203-2 * Database: C:\Users\A8AC9~1.ZYA\AppData\Local\Temp\{189B5158-AE35-4061-B696-B514458B5062}\ifc * Database version: 5507 * Database creation date: Tue Sep 22 16:38:53 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Sep 22 16:38:54 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 22 16:38:54 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
Phase: П

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель; Название организации: Название организации
Прочее - Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Категория: Сведения о проекте; Статус проекта: П

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Данные - ADSK_Титул_Год выпуска: 2019
Идентификация - Вариант конструкции: Главная модель; Название организации: Название организации
Прочее - Категория: Сведения о проекте; Адрес проекта: Адрес проекта; Дата утверждения проекта: Дата; Заказчик: Заказчик; Статус проекта: П

# IfcBuildingStorey, Этаж 01
LongName: Этаж 01; Elevation: 0 mm
Прочее - Категория: Уровни; Имя семейства: Уровень; Код типа: Уровень: Отметка уровня с именем; Семейство: Уровень: Отметка уровня с именем; Семейство и типоразмер: Уровень: Отметка уровня с именем; Тип: Уровень: Отметка уровня с именем
Зависимости - Фасад: 0 mm; Базовая отметка: Базовая точка проекта
Идентификация - Вариант конструкции: Главная модель; Имя: Этаж 01; Несущие конструкции: no; Построение этажа: yes; Имя типа: Отметка уровня с именем
Размеры - Расчетная высота: 0 mm
Графика - Вес линий: 1; Обозначение: ADSK_ОтметкаУровня_ГОСТ21-1101-2013: Уровень с именем; Образец линий: ADSK_Линия сетки; Стандартное обозначение второго конца: yes; Стандартное обозначение первого конца: yes; Цвет: 16711680

# IfcFlowTerminal: 100х100х650, BIMLIB_Воронка_Fachmann_VC-PP:100х100х650:267468
In: Этаж 01
Material: Fachmann_ПВХ_Черный
Pset_ManufacturerTypeInformation - Manufacturer: Fachmann
Pset_DistributionFlowElementCommon - Reference: 100х100х650
Зависимости - Рабочая плоскость: Уровень : Этаж 01; Смещение: 0 mm; Уровень: Уровень: Этаж 01; Отметка по умолчанию: 1219.2 mm
Идентификация - Марка: 30; ADSK_Версия семейства: 1; URL: https://fachmann-rus.ru/; Заголовок OmniClass: Roof Waste Water Drains; Изготовитель: Fachmann; Имя типа: 100х100х650; Номер OmniClass: 23.70.50.21.24.11; Описание: Парапетная воронка для полимер-битумной изоляции VC-PP 100x100 применяется для организации внешнего водостока через балконы и парапеты на пониженных участках кровли. Воронка имеет квадратное сечение отводящей трубы и изготавливается из морозостойкого полипропилена, который обеспечивает высокую надежность и стойкость к воздействиям внешней среды на кровле. Еще одной отличительной особенностью является увеличенный фланец 454x244 мм и увеличенный выпуск 650 мм. Воронка поставляется c угловым отводом, для соединения с водосточными трубами диаметром 100 мм и листвоуловителем, который позволяет предотвратить попадание веток, листьев и прочего мусора в ливневую канализацию.; Производитель_Контакты: Email: all@fachmann-rus.ru; Тел: 8 (800) 511-07-21; Разработчик_Контакты: support@bimlib.pro
Механизмы - ADSK_Расход жидкости: 0 m3/s; Классификация систем: Не определено; Fachmann_МаксимальныйРасход: 0.282517 m3/s
Прочее - Категория: Сантехнические приборы; Код типа: BIMLIB_Воронка_Fachmann_VC-PP: 100х100х650; Семейство: BIMLIB_Воронка_Fachmann_VC-PP: 100х100х650; Семейство и типоразмер: BIMLIB_Воронка_Fachmann_VC-PP: 100х100х650; Тип: BIMLIB_Воронка_Fachmann_VC-PP: 100х100х650; Уровень спецификации: Уровень: Этаж 01; Имя семейства: BIMLIB_Воронка_Fachmann_VC-PP
Размеры - Объем: 0.00873058 m3; ADSK_Диаметр условный: 100 mm; D_Листоуловитель: 164 mm; Fachmann_ВысотаВыпускногоПатрубка: 650 mm; СечениеПриемнойВоронки: 100 mm; ФланецВысота: 244 mm; ФланецГлубина: 181 mm; ФланецШирина: 454 mm
Стадии - Стадия возведения: ПРОЕКТ
Данные - ADSK_URL документации изделия: https://kirov.fachmann-rus.ru/upload/iblock/76f/76f428e357b76a5197bb952aaa8532f7.pdf; ADSK_URL страницы изделия: https://kirov.fachmann-rus.ru/catalog/parapetnye-voronki/295/; ADSK_Версия Revit: 2017; ADSK_Единица измерения: шт.; ADSK_Завод-изготовитель: Fachmann; ADSK_Код изделия: 22.21.21.12.1.01.04; ADSK_Количество: 1; ADSK_Марка: VC-PP 100x100х650; ADSK_Наименование: Парапетная воронка для полимер-битумной изоляции VC-PP 100x100х650 (арт. 01.068); ADSK_Наименование краткое: Парапетная воронка VC-PP 100x100х650
Текст - Fachmann_Артикул: 01.068; Fachmann_МаксимальнаяТемператураВнутреннейПоверхностиВоронки: +55 °С; Fachmann_СрокСлужбы: не менее 50 лет; Fachmann_ТемператураОкружающейСреды: от -50 °С до +90 °С; Fachmann_ТемператураОтводящейЖидкости: не более +85 °С
